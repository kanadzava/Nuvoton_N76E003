# Keil uVision project ADC.uvproj, settings and files
target ADC (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ADC_Bandgap_VDD +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  asm include: .\Startup
  group code
    ./Code/: ADC_BG_VDD_avg_new.c
  group Startup
    ./Startup/: STARTUP.A51
